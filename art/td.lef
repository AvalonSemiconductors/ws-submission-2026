VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO td
  CLASS BLOCK ;
  FOREIGN td ;
  ORIGIN 0.000 0.000 ;
  SIZE 76.800 BY 76.800 ;
  OBS
      LAYER Metal5 ;
        RECT 37.800 72.000 39.000 73.200 ;
        RECT 37.200 70.800 39.600 72.000 ;
        RECT 36.600 70.200 40.200 70.800 ;
        RECT 36.000 69.000 40.800 70.200 ;
        RECT 35.400 67.800 41.400 69.000 ;
        RECT 34.800 66.600 42.000 67.800 ;
        RECT 34.200 66.000 42.600 66.600 ;
        RECT 33.600 64.800 43.200 66.000 ;
        RECT 33.000 63.600 43.800 64.800 ;
        RECT 32.400 63.000 44.400 63.600 ;
        RECT 32.400 62.400 37.800 63.000 ;
        RECT 31.800 61.800 37.800 62.400 ;
        RECT 39.000 62.400 44.400 63.000 ;
        RECT 39.000 61.800 45.000 62.400 ;
        RECT 31.200 60.600 37.200 61.800 ;
        RECT 39.600 60.600 45.600 61.800 ;
        RECT 30.600 60.000 34.200 60.600 ;
        RECT 40.200 60.000 46.200 60.600 ;
        RECT 30.600 59.400 31.200 60.000 ;
        RECT 40.800 59.400 46.200 60.000 ;
        RECT 33.000 58.800 39.600 59.400 ;
        RECT 40.800 58.800 46.800 59.400 ;
        RECT 30.600 58.200 40.200 58.800 ;
        RECT 41.400 58.200 46.800 58.800 ;
        RECT 28.800 57.600 40.800 58.200 ;
        RECT 41.400 57.600 47.400 58.200 ;
        RECT 27.000 57.000 40.800 57.600 ;
        RECT 25.800 56.400 41.400 57.000 ;
        RECT 42.000 56.400 48.000 57.600 ;
        RECT 48.600 57.000 49.800 57.600 ;
        RECT 49.200 56.400 51.000 57.000 ;
        RECT 24.600 55.800 41.400 56.400 ;
        RECT 42.600 55.800 48.600 56.400 ;
        RECT 23.400 55.200 42.000 55.800 ;
        RECT 22.800 54.600 42.000 55.200 ;
        RECT 43.200 55.200 48.600 55.800 ;
        RECT 49.800 55.800 52.200 56.400 ;
        RECT 49.800 55.200 53.400 55.800 ;
        RECT 43.200 54.600 49.200 55.200 ;
        RECT 21.600 54.000 34.800 54.600 ;
        RECT 43.800 54.000 49.200 54.600 ;
        RECT 50.400 54.600 54.000 55.200 ;
        RECT 50.400 54.000 55.200 54.600 ;
        RECT 21.000 53.400 31.800 54.000 ;
        RECT 43.800 53.400 49.800 54.000 ;
        RECT 51.000 53.400 55.800 54.000 ;
        RECT 20.400 52.800 30.000 53.400 ;
        RECT 19.800 52.200 28.800 52.800 ;
        RECT 31.200 52.200 31.800 52.800 ;
        RECT 44.400 52.200 50.400 53.400 ;
        RECT 51.000 52.800 56.400 53.400 ;
        RECT 51.600 52.200 57.000 52.800 ;
        RECT 19.200 51.600 27.600 52.200 ;
        RECT 29.400 51.600 31.800 52.200 ;
        RECT 45.000 51.600 51.000 52.200 ;
        RECT 18.600 51.000 26.400 51.600 ;
        RECT 28.200 51.000 31.200 51.600 ;
        RECT 18.000 50.400 25.800 51.000 ;
        RECT 27.000 50.400 31.200 51.000 ;
        RECT 45.600 51.000 51.000 51.600 ;
        RECT 52.200 51.600 57.600 52.200 ;
        RECT 52.200 51.000 58.200 51.600 ;
        RECT 45.600 50.400 51.600 51.000 ;
        RECT 52.800 50.400 58.800 51.000 ;
        RECT 17.400 49.800 24.600 50.400 ;
        RECT 26.400 49.800 30.600 50.400 ;
        RECT 16.800 49.200 24.000 49.800 ;
        RECT 25.200 49.200 30.600 49.800 ;
        RECT 46.200 49.200 52.200 50.400 ;
        RECT 52.800 49.800 59.400 50.400 ;
        RECT 53.400 49.200 60.000 49.800 ;
        RECT 16.200 48.600 23.400 49.200 ;
        RECT 24.600 48.600 30.000 49.200 ;
        RECT 46.800 48.600 52.800 49.200 ;
        RECT 53.400 48.600 60.600 49.200 ;
        RECT 15.600 48.000 22.800 48.600 ;
        RECT 24.000 48.000 29.400 48.600 ;
        RECT 15.600 47.400 21.600 48.000 ;
        RECT 15.000 46.800 21.600 47.400 ;
        RECT 23.400 47.400 29.400 48.000 ;
        RECT 47.400 48.000 52.800 48.600 ;
        RECT 54.000 48.000 61.200 48.600 ;
        RECT 47.400 47.400 53.400 48.000 ;
        RECT 23.400 46.800 28.800 47.400 ;
        RECT 14.400 46.200 21.000 46.800 ;
        RECT 22.800 46.200 28.800 46.800 ;
        RECT 48.000 46.800 53.400 47.400 ;
        RECT 55.200 47.400 61.200 48.000 ;
        RECT 55.200 46.800 61.800 47.400 ;
        RECT 48.000 46.200 54.000 46.800 ;
        RECT 55.800 46.200 62.400 46.800 ;
        RECT 14.400 45.600 20.400 46.200 ;
        RECT 13.800 45.000 19.800 45.600 ;
        RECT 22.200 45.000 28.200 46.200 ;
        RECT 48.600 45.000 54.600 46.200 ;
        RECT 56.400 45.600 62.400 46.200 ;
        RECT 57.000 45.000 63.000 45.600 ;
        RECT 13.200 43.800 19.200 45.000 ;
        RECT 21.600 44.400 27.600 45.000 ;
        RECT 49.200 44.400 55.200 45.000 ;
        RECT 21.600 43.800 27.000 44.400 ;
        RECT 12.600 43.200 18.600 43.800 ;
        RECT 21.000 43.200 27.000 43.800 ;
        RECT 49.800 43.800 55.200 44.400 ;
        RECT 57.600 43.800 63.600 45.000 ;
        RECT 49.800 43.200 55.800 43.800 ;
        RECT 58.200 43.200 64.200 43.800 ;
        RECT 12.600 42.000 18.000 43.200 ;
        RECT 21.000 42.600 26.400 43.200 ;
        RECT 20.400 42.000 26.400 42.600 ;
        RECT 50.400 42.600 55.800 43.200 ;
        RECT 50.400 42.000 56.400 42.600 ;
        RECT 58.800 42.000 64.200 43.200 ;
        RECT 12.000 40.800 17.400 42.000 ;
        RECT 19.800 40.800 25.800 42.000 ;
        RECT 51.000 40.800 57.000 42.000 ;
        RECT 59.400 40.800 64.800 42.000 ;
        RECT 11.400 39.000 16.800 40.800 ;
        RECT 19.200 40.200 25.200 40.800 ;
        RECT 51.600 40.200 57.600 40.800 ;
        RECT 19.200 39.600 24.600 40.200 ;
        RECT 18.600 39.000 24.600 39.600 ;
        RECT 52.200 39.600 57.600 40.200 ;
        RECT 52.200 39.000 58.200 39.600 ;
        RECT 60.000 39.000 65.400 40.800 ;
        RECT 11.400 38.400 16.200 39.000 ;
        RECT 18.600 38.400 24.000 39.000 ;
        RECT 10.800 37.200 16.200 38.400 ;
        RECT 18.000 37.800 24.000 38.400 ;
        RECT 52.800 38.400 58.200 39.000 ;
        RECT 60.600 38.400 65.400 39.000 ;
        RECT 52.800 37.800 58.800 38.400 ;
        RECT 10.800 36.000 15.600 37.200 ;
        RECT 17.400 36.600 23.400 37.800 ;
        RECT 53.400 36.600 59.400 37.800 ;
        RECT 60.600 37.200 66.000 38.400 ;
        RECT 10.200 35.400 15.600 36.000 ;
        RECT 16.800 36.000 22.800 36.600 ;
        RECT 54.000 36.000 60.000 36.600 ;
        RECT 16.800 35.400 22.200 36.000 ;
        RECT 10.200 34.200 15.000 35.400 ;
        RECT 16.200 34.800 22.200 35.400 ;
        RECT 54.600 35.400 60.000 36.000 ;
        RECT 61.200 36.000 66.000 37.200 ;
        RECT 54.600 34.800 60.600 35.400 ;
        RECT 16.200 34.200 21.600 34.800 ;
        RECT 10.200 33.000 14.400 34.200 ;
        RECT 15.600 33.600 21.600 34.200 ;
        RECT 10.200 32.400 13.800 33.000 ;
        RECT 15.000 32.400 21.000 33.600 ;
        RECT 30.600 33.000 31.200 34.800 ;
        RECT 45.600 33.000 46.200 34.800 ;
        RECT 55.200 33.600 60.600 34.800 ;
        RECT 61.200 33.600 66.600 36.000 ;
        RECT 10.200 31.200 13.200 32.400 ;
        RECT 14.400 31.800 20.400 32.400 ;
        RECT 14.400 31.200 19.800 31.800 ;
        RECT 10.200 30.000 12.600 31.200 ;
        RECT 13.800 30.600 19.800 31.200 ;
        RECT 10.200 28.800 12.000 30.000 ;
        RECT 13.200 29.400 19.200 30.600 ;
        RECT 30.600 29.400 46.200 33.000 ;
        RECT 55.800 32.400 60.600 33.600 ;
        RECT 56.400 31.800 60.600 32.400 ;
        RECT 57.000 30.600 60.600 31.800 ;
        RECT 57.600 29.400 60.600 30.600 ;
        RECT 61.800 29.400 66.600 33.600 ;
        RECT 12.600 28.800 18.600 29.400 ;
        RECT 10.200 28.200 11.400 28.800 ;
        RECT 12.600 28.200 18.000 28.800 ;
        RECT 30.600 28.200 31.200 29.400 ;
        RECT 45.600 28.200 46.200 29.400 ;
        RECT 58.200 28.800 60.600 29.400 ;
        RECT 10.200 27.600 10.800 28.200 ;
        RECT 12.000 27.600 18.000 28.200 ;
        RECT 58.800 27.600 60.600 28.800 ;
        RECT 12.000 27.000 17.400 27.600 ;
        RECT 11.400 26.400 17.400 27.000 ;
        RECT 59.400 26.400 60.000 27.600 ;
        RECT 61.200 27.000 66.600 29.400 ;
        RECT 10.800 25.200 16.800 26.400 ;
        RECT 61.200 25.800 66.000 27.000 ;
        RECT 10.200 24.600 16.200 25.200 ;
        RECT 10.200 24.000 15.600 24.600 ;
        RECT 60.600 24.000 66.000 25.800 ;
        RECT 9.600 23.400 15.600 24.000 ;
        RECT 9.600 22.800 15.000 23.400 ;
        RECT 16.200 22.800 16.800 23.400 ;
        RECT 9.000 22.200 15.000 22.800 ;
        RECT 15.600 22.200 16.800 22.800 ;
        RECT 60.000 22.200 65.400 24.000 ;
        RECT 66.600 22.800 67.200 24.000 ;
        RECT 66.000 22.200 67.800 22.800 ;
        RECT 8.400 21.000 14.400 22.200 ;
        RECT 15.600 21.600 17.400 22.200 ;
        RECT 15.000 21.000 17.400 21.600 ;
        RECT 59.400 21.000 64.800 22.200 ;
        RECT 66.000 21.000 68.400 22.200 ;
        RECT 7.800 20.400 13.800 21.000 ;
        RECT 15.000 20.400 18.000 21.000 ;
        RECT 7.800 19.800 13.200 20.400 ;
        RECT 7.200 19.200 13.200 19.800 ;
        RECT 14.400 19.800 18.000 20.400 ;
        RECT 58.800 20.400 64.800 21.000 ;
        RECT 58.800 19.800 64.200 20.400 ;
        RECT 65.400 19.800 69.000 21.000 ;
        RECT 14.400 19.200 18.600 19.800 ;
        RECT 7.200 18.600 12.600 19.200 ;
        RECT 6.600 18.000 12.600 18.600 ;
        RECT 13.800 18.600 18.600 19.200 ;
        RECT 58.200 19.200 64.200 19.800 ;
        RECT 58.200 18.600 63.600 19.200 ;
        RECT 64.800 18.600 69.600 19.800 ;
        RECT 13.800 18.000 19.200 18.600 ;
        RECT 57.600 18.000 63.600 18.600 ;
        RECT 64.200 18.000 70.200 18.600 ;
        RECT 6.000 16.800 12.000 18.000 ;
        RECT 13.800 17.400 19.800 18.000 ;
        RECT 57.000 17.400 63.000 18.000 ;
        RECT 13.800 16.800 20.400 17.400 ;
        RECT 5.400 16.200 11.400 16.800 ;
        RECT 14.400 16.200 20.400 16.800 ;
        RECT 56.400 16.800 63.000 17.400 ;
        RECT 64.800 16.800 70.800 18.000 ;
        RECT 56.400 16.200 62.400 16.800 ;
        RECT 65.400 16.200 71.400 16.800 ;
        RECT 5.400 15.600 10.800 16.200 ;
        RECT 15.000 15.600 21.000 16.200 ;
        RECT 66.000 15.600 71.400 16.200 ;
        RECT 4.800 15.000 13.800 15.600 ;
        RECT 15.000 15.000 21.600 15.600 ;
        RECT 4.800 14.400 14.400 15.000 ;
        RECT 15.600 14.400 22.200 15.000 ;
        RECT 23.400 14.400 72.000 15.600 ;
        RECT 4.200 13.800 15.000 14.400 ;
        RECT 16.200 13.800 22.800 14.400 ;
        RECT 24.600 13.800 72.600 14.400 ;
        RECT 3.600 13.200 15.600 13.800 ;
        RECT 16.800 13.200 24.000 13.800 ;
        RECT 25.200 13.200 73.200 13.800 ;
        RECT 3.600 12.600 16.200 13.200 ;
        RECT 3.000 12.000 16.200 12.600 ;
        RECT 17.400 12.600 24.600 13.200 ;
        RECT 25.800 12.600 73.200 13.200 ;
        RECT 17.400 12.000 25.200 12.600 ;
        RECT 27.000 12.000 73.800 12.600 ;
        RECT 3.000 11.400 16.800 12.000 ;
        RECT 18.000 11.400 26.400 12.000 ;
        RECT 28.200 11.400 73.800 12.000 ;
        RECT 2.400 10.800 17.400 11.400 ;
        RECT 18.600 10.800 27.000 11.400 ;
        RECT 29.400 10.800 74.400 11.400 ;
        RECT 2.400 10.200 18.000 10.800 ;
        RECT 19.200 10.200 28.200 10.800 ;
        RECT 30.600 10.200 74.400 10.800 ;
        RECT 20.400 9.600 30.000 10.200 ;
        RECT 21.000 9.000 31.200 9.600 ;
        RECT 45.600 9.000 55.800 9.600 ;
        RECT 21.600 8.400 33.600 9.000 ;
        RECT 43.200 8.400 55.200 9.000 ;
        RECT 22.800 7.800 54.000 8.400 ;
        RECT 23.400 7.200 53.400 7.800 ;
        RECT 24.600 6.600 52.200 7.200 ;
        RECT 25.800 6.000 51.000 6.600 ;
        RECT 27.000 5.400 49.800 6.000 ;
        RECT 28.200 4.800 48.600 5.400 ;
        RECT 30.000 4.200 46.800 4.800 ;
        RECT 32.400 3.600 44.400 4.200 ;
        RECT 36.000 3.000 40.800 3.600 ;
  END
END td
END LIBRARY

