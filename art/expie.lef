VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO expie
  CLASS BLOCK ;
  FOREIGN expie ;
  ORIGIN 0.000 0.000 ;
  SIZE 84.000 BY 72.000 ;
  OBS
      LAYER Metal3 ;
        RECT 43.200 60.000 45.000 63.600 ;
        RECT 2.400 31.800 4.200 35.400 ;
        RECT 18.600 28.200 21.000 30.000 ;
        RECT 20.400 26.400 24.000 28.200 ;
        RECT 3.000 15.000 4.800 15.600 ;
        RECT 2.400 14.400 4.800 15.000 ;
        RECT 1.800 13.800 3.600 14.400 ;
        RECT 1.800 13.200 3.000 13.800 ;
        RECT 6.000 13.200 7.200 20.400 ;
        RECT 10.800 15.600 12.000 20.400 ;
        RECT 13.200 17.400 14.400 20.400 ;
        RECT 15.600 19.800 16.800 20.400 ;
        RECT 15.600 19.200 17.400 19.800 ;
        RECT 16.200 18.600 18.000 19.200 ;
        RECT 16.800 17.400 18.600 18.600 ;
        RECT 20.400 17.400 21.600 20.400 ;
        RECT 22.800 18.000 24.000 18.600 ;
        RECT 22.800 17.400 24.600 18.000 ;
        RECT 17.400 16.800 19.200 17.400 ;
        RECT 23.400 16.800 24.600 17.400 ;
        RECT 18.000 16.200 19.800 16.800 ;
        RECT 18.600 15.600 20.400 16.200 ;
        RECT 8.400 15.000 10.200 15.600 ;
        RECT 8.400 14.400 10.800 15.000 ;
        RECT 19.200 14.400 21.000 15.600 ;
        RECT 9.000 13.800 11.400 14.400 ;
        RECT 9.600 13.200 11.400 13.800 ;
        RECT 15.600 13.200 18.000 14.400 ;
        RECT 19.800 13.800 21.600 14.400 ;
        RECT 20.400 13.200 21.600 13.800 ;
        RECT 25.800 13.200 27.600 20.400 ;
        RECT 37.800 19.200 39.600 20.400 ;
        RECT 43.200 19.800 44.400 20.400 ;
        RECT 43.200 19.200 45.000 19.800 ;
        RECT 35.400 18.000 42.000 19.200 ;
        RECT 43.800 18.600 45.600 19.200 ;
        RECT 28.200 16.200 29.400 16.800 ;
        RECT 28.200 15.600 30.000 16.200 ;
        RECT 28.800 15.000 30.600 15.600 ;
        RECT 35.400 13.200 36.600 16.200 ;
        RECT 37.800 13.200 39.600 18.000 ;
        RECT 44.400 17.400 46.200 18.600 ;
        RECT 48.000 17.400 49.200 20.400 ;
        RECT 55.800 19.800 57.000 20.400 ;
        RECT 52.200 19.200 54.000 19.800 ;
        RECT 55.800 19.200 57.600 19.800 ;
        RECT 51.600 18.600 54.000 19.200 ;
        RECT 56.400 18.600 58.200 19.200 ;
        RECT 51.000 18.000 53.400 18.600 ;
        RECT 51.000 17.400 52.800 18.000 ;
        RECT 57.000 17.400 58.800 18.600 ;
        RECT 60.600 17.400 61.800 20.400 ;
        RECT 65.400 19.200 68.400 20.400 ;
        RECT 45.000 16.800 46.800 17.400 ;
        RECT 57.600 16.800 59.400 17.400 ;
        RECT 45.600 16.200 47.400 16.800 ;
        RECT 58.200 16.200 60.000 16.800 ;
        RECT 40.800 15.600 41.400 16.200 ;
        RECT 46.200 15.600 48.000 16.200 ;
        RECT 52.200 15.600 54.000 16.200 ;
        RECT 58.800 15.600 60.600 16.200 ;
        RECT 40.200 13.200 42.000 15.600 ;
        RECT 46.800 14.400 48.600 15.600 ;
        RECT 50.400 14.400 54.600 15.600 ;
        RECT 59.400 14.400 61.200 15.600 ;
        RECT 43.200 13.200 45.600 14.400 ;
        RECT 47.400 13.800 49.200 14.400 ;
        RECT 51.000 13.800 52.800 14.400 ;
        RECT 48.000 13.200 49.200 13.800 ;
        RECT 55.800 13.200 58.200 14.400 ;
        RECT 60.000 13.800 61.800 14.400 ;
        RECT 60.600 13.200 61.800 13.800 ;
        RECT 63.000 13.200 65.400 14.400 ;
        RECT 66.600 13.200 68.400 18.000 ;
        RECT 69.600 13.200 71.400 20.400 ;
        RECT 72.000 14.400 73.800 20.400 ;
        RECT 76.200 19.800 77.400 20.400 ;
        RECT 76.200 19.200 78.000 19.800 ;
        RECT 76.800 18.600 78.600 19.200 ;
        RECT 77.400 17.400 79.200 18.600 ;
        RECT 81.000 17.400 82.200 20.400 ;
        RECT 78.000 16.800 79.800 17.400 ;
        RECT 78.600 16.200 80.400 16.800 ;
        RECT 79.200 15.600 81.000 16.200 ;
        RECT 79.800 14.400 81.600 15.600 ;
        RECT 72.000 13.200 75.000 14.400 ;
        RECT 76.200 13.200 78.600 14.400 ;
        RECT 80.400 13.800 82.200 14.400 ;
        RECT 81.000 13.200 82.200 13.800 ;
        RECT 20.400 7.800 21.600 10.800 ;
        RECT 22.800 3.600 24.600 10.800 ;
        RECT 25.200 8.400 26.400 10.800 ;
        RECT 28.200 10.200 29.400 10.800 ;
        RECT 28.200 9.600 30.000 10.200 ;
        RECT 28.800 9.000 30.600 9.600 ;
        RECT 25.800 7.800 26.400 8.400 ;
        RECT 29.400 7.800 31.200 9.000 ;
        RECT 33.000 7.800 34.200 10.800 ;
        RECT 30.000 7.200 31.800 7.800 ;
        RECT 30.600 6.600 32.400 7.200 ;
        RECT 31.200 6.000 33.000 6.600 ;
        RECT 31.800 4.800 33.600 6.000 ;
        RECT 36.600 5.400 38.400 6.000 ;
        RECT 36.000 4.800 38.400 5.400 ;
        RECT 28.200 3.600 30.600 4.800 ;
        RECT 32.400 4.200 34.200 4.800 ;
        RECT 33.000 3.600 34.200 4.200 ;
        RECT 35.400 4.200 37.200 4.800 ;
        RECT 35.400 3.600 36.600 4.200 ;
        RECT 39.600 3.600 40.800 10.800 ;
        RECT 43.200 5.400 45.000 6.000 ;
        RECT 42.600 4.800 45.000 5.400 ;
        RECT 42.000 4.200 43.800 4.800 ;
        RECT 42.000 3.600 43.200 4.200 ;
        RECT 46.200 3.600 47.400 10.800 ;
        RECT 48.600 10.200 49.800 10.800 ;
        RECT 48.600 9.600 50.400 10.200 ;
        RECT 49.200 9.000 51.000 9.600 ;
        RECT 49.800 7.800 51.600 9.000 ;
        RECT 53.400 7.800 54.600 10.800 ;
        RECT 58.200 9.600 61.200 10.800 ;
        RECT 50.400 7.200 52.200 7.800 ;
        RECT 51.000 6.600 52.800 7.200 ;
        RECT 51.600 6.000 53.400 6.600 ;
        RECT 52.200 4.800 54.000 6.000 ;
        RECT 48.600 3.600 51.000 4.800 ;
        RECT 52.800 4.200 54.600 4.800 ;
        RECT 53.400 3.600 54.600 4.200 ;
        RECT 55.800 3.600 58.200 4.800 ;
        RECT 59.400 3.600 61.200 8.400 ;
        RECT 62.400 5.400 63.600 10.200 ;
        RECT 62.400 3.600 63.600 4.800 ;
      LAYER Metal4 ;
        RECT 0.000 71.400 84.000 72.000 ;
        RECT 50.400 60.000 54.000 61.800 ;
        RECT 48.600 56.400 52.200 60.000 ;
        RECT 70.200 35.400 78.600 37.200 ;
        RECT 68.400 33.600 80.400 35.400 ;
        RECT 70.200 31.800 77.400 33.600 ;
        RECT 71.400 30.000 82.200 31.800 ;
        RECT 66.600 28.200 68.400 30.000 ;
        RECT 70.200 28.200 80.400 30.000 ;
        RECT 67.800 26.400 77.400 28.200 ;
        RECT 0.000 0.000 84.000 0.600 ;
      LAYER Metal5 ;
        RECT 0.000 0.000 0.600 72.000 ;
        RECT 1.200 69.000 2.400 69.600 ;
        RECT 1.200 68.400 3.000 69.000 ;
        RECT 1.800 67.800 3.600 68.400 ;
        RECT 2.400 67.200 4.200 67.800 ;
        RECT 2.400 66.600 4.800 67.200 ;
        RECT 6.000 66.600 7.800 69.600 ;
        RECT 9.000 69.000 10.200 69.600 ;
        RECT 12.600 69.000 13.800 69.600 ;
        RECT 9.000 68.400 11.400 69.000 ;
        RECT 9.600 67.800 11.400 68.400 ;
        RECT 12.600 68.400 14.400 69.000 ;
        RECT 16.200 68.400 21.000 69.600 ;
        RECT 12.600 67.800 15.000 68.400 ;
        RECT 10.200 67.200 11.400 67.800 ;
        RECT 13.200 67.200 15.000 67.800 ;
        RECT 3.000 66.000 4.800 66.600 ;
        RECT 3.600 65.400 5.400 66.000 ;
        RECT 13.200 65.400 15.000 66.000 ;
        RECT 4.200 64.800 6.000 65.400 ;
        RECT 12.600 64.800 15.000 65.400 ;
        RECT 4.200 64.200 6.600 64.800 ;
        RECT 12.000 64.200 14.400 64.800 ;
        RECT 4.800 63.600 6.600 64.200 ;
        RECT 11.400 63.600 13.800 64.200 ;
        RECT 5.400 63.000 7.200 63.600 ;
        RECT 10.800 63.000 13.200 63.600 ;
        RECT 1.200 61.800 4.200 63.000 ;
        RECT 6.000 62.400 7.800 63.000 ;
        RECT 6.600 61.800 7.800 62.400 ;
        RECT 10.200 62.400 12.000 63.000 ;
        RECT 10.200 61.800 11.400 62.400 ;
        RECT 19.800 61.800 21.000 67.200 ;
        RECT 22.800 66.600 24.600 69.600 ;
        RECT 28.200 68.400 30.000 69.600 ;
        RECT 31.200 69.000 32.400 69.600 ;
        RECT 31.200 68.400 33.000 69.000 ;
        RECT 27.600 67.800 30.000 68.400 ;
        RECT 31.800 67.800 33.600 68.400 ;
        RECT 27.000 67.200 30.000 67.800 ;
        RECT 26.400 66.600 30.000 67.200 ;
        RECT 32.400 67.200 34.200 67.800 ;
        RECT 32.400 66.600 34.800 67.200 ;
        RECT 36.000 66.600 37.800 69.600 ;
        RECT 52.200 67.200 68.400 69.000 ;
        RECT 25.800 66.000 30.000 66.600 ;
        RECT 33.000 66.000 34.800 66.600 ;
        RECT 25.200 65.400 27.600 66.000 ;
        RECT 24.600 64.800 27.000 65.400 ;
        RECT 24.000 64.200 26.400 64.800 ;
        RECT 24.000 63.600 25.800 64.200 ;
        RECT 23.400 63.000 25.200 63.600 ;
        RECT 22.800 62.400 24.600 63.000 ;
        RECT 22.800 61.800 24.000 62.400 ;
        RECT 28.200 61.800 30.000 66.000 ;
        RECT 33.600 65.400 35.400 66.000 ;
        RECT 46.800 65.400 52.800 67.200 ;
        RECT 67.800 65.400 70.200 67.200 ;
        RECT 34.200 64.800 36.000 65.400 ;
        RECT 34.200 64.200 36.600 64.800 ;
        RECT 34.800 63.600 36.600 64.200 ;
        RECT 42.600 63.600 47.400 65.400 ;
        RECT 69.600 63.600 73.200 65.400 ;
        RECT 35.400 63.000 37.200 63.600 ;
        RECT 31.200 61.800 34.200 63.000 ;
        RECT 36.000 62.400 37.800 63.000 ;
        RECT 36.600 61.800 37.800 62.400 ;
        RECT 41.400 56.400 43.200 63.600 ;
        RECT 72.600 61.800 75.600 63.600 ;
        RECT 54.000 60.000 55.800 61.800 ;
        RECT 75.000 60.000 77.400 61.800 ;
        RECT 52.200 58.200 55.800 60.000 ;
        RECT 62.400 58.200 75.600 60.000 ;
        RECT 52.200 56.400 54.000 58.200 ;
        RECT 61.200 56.400 63.000 58.200 ;
        RECT 42.600 55.200 45.000 56.400 ;
        RECT 62.400 55.200 64.800 56.400 ;
        RECT 42.600 54.600 49.200 55.200 ;
        RECT 62.400 54.600 67.800 55.200 ;
        RECT 45.000 53.400 49.200 54.600 ;
        RECT 64.200 54.000 67.800 54.600 ;
        RECT 64.200 53.400 69.600 54.000 ;
        RECT 48.600 51.600 51.000 53.400 ;
        RECT 67.800 52.800 69.600 53.400 ;
        RECT 67.800 52.200 71.400 52.800 ;
        RECT 69.600 51.600 71.400 52.200 ;
        RECT 50.400 49.200 52.200 51.600 ;
        RECT 69.600 51.000 73.200 51.600 ;
        RECT 57.000 49.200 61.800 51.000 ;
        RECT 71.400 49.200 73.200 51.000 ;
        RECT 28.800 47.400 32.400 49.200 ;
        RECT 48.000 47.400 51.000 49.200 ;
        RECT 27.600 44.400 29.400 47.400 ;
        RECT 31.800 46.200 34.200 47.400 ;
        RECT 31.800 45.600 36.000 46.200 ;
        RECT 25.800 43.800 29.400 44.400 ;
        RECT 25.800 39.000 27.600 43.800 ;
        RECT 34.200 42.600 36.000 45.600 ;
        RECT 46.800 42.600 48.600 47.400 ;
        RECT 35.400 40.800 38.400 42.600 ;
        RECT 45.000 40.800 47.400 42.600 ;
        RECT 37.800 39.000 40.200 40.800 ;
        RECT 43.200 39.000 45.600 40.800 ;
        RECT 3.600 37.200 7.800 39.000 ;
        RECT 24.000 37.200 27.600 39.000 ;
        RECT 2.400 35.400 4.200 37.200 ;
        RECT 7.200 35.400 9.600 37.200 ;
        RECT 18.000 35.400 25.800 37.200 ;
        RECT 9.000 33.600 18.600 35.400 ;
        RECT 22.200 33.600 24.000 35.400 ;
        RECT 31.200 33.600 32.400 39.000 ;
        RECT 39.600 37.200 43.800 39.000 ;
        RECT 50.400 37.800 52.200 47.400 ;
        RECT 55.800 45.000 57.600 49.200 ;
        RECT 61.200 47.400 72.000 49.200 ;
        RECT 55.800 44.400 59.400 45.000 ;
        RECT 57.600 42.600 59.400 44.400 ;
        RECT 58.800 40.800 61.200 42.600 ;
        RECT 57.600 39.000 59.400 40.800 ;
        RECT 64.200 39.000 71.400 40.800 ;
        RECT 50.400 37.200 54.000 37.800 ;
        RECT 56.400 37.200 58.200 39.000 ;
        RECT 61.200 37.200 64.800 39.000 ;
        RECT 68.400 37.200 70.200 39.000 ;
        RECT 4.200 31.800 6.000 33.600 ;
        RECT 18.000 31.800 22.800 33.600 ;
        RECT 29.400 32.400 32.400 33.600 ;
        RECT 52.200 32.400 54.000 37.200 ;
        RECT 29.400 31.800 34.200 32.400 ;
        RECT 5.400 30.000 7.800 31.800 ;
        RECT 7.200 28.200 9.600 30.000 ;
        RECT 16.800 28.200 18.600 31.800 ;
        RECT 29.400 30.000 31.200 31.800 ;
        RECT 27.600 29.400 31.200 30.000 ;
        RECT 27.600 28.200 29.400 29.400 ;
        RECT 32.400 28.200 34.200 31.800 ;
        RECT 50.400 31.800 54.000 32.400 ;
        RECT 57.600 35.400 61.800 37.200 ;
        RECT 57.600 31.800 59.400 35.400 ;
        RECT 50.400 30.000 52.200 31.800 ;
        RECT 56.400 30.000 58.800 31.800 ;
        RECT 46.200 28.200 52.200 30.000 ;
        RECT 55.800 28.200 57.600 30.000 ;
        RECT 9.000 27.600 20.400 28.200 ;
        RECT 9.000 26.400 16.800 27.600 ;
        RECT 18.600 26.400 20.400 27.600 ;
        RECT 25.800 27.600 29.400 28.200 ;
        RECT 25.800 26.400 27.600 27.600 ;
        RECT 33.600 26.400 46.800 28.200 ;
        RECT 51.000 26.400 66.600 28.200 ;
        RECT 18.600 25.800 27.600 26.400 ;
        RECT 20.400 24.600 25.800 25.800 ;
        RECT 83.400 0.000 84.000 72.000 ;
  END
END expie
END LIBRARY

